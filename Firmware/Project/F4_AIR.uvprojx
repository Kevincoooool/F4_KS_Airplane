# Keil uVision project F4_AIR.uvprojx, settings and files
target F4_AIR (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F4_AIR +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,__FPU_PRESENT = 1,__TARGET_FPU_VFP,__FPU_USED = 1, __CC_ARM,USE_STDPERIPH_DRIVER,ARM_MATH_CM4,USE_USB_OTG_FS
  c misc: --c99
  c include: ..\Libraries\CMSIS\Device;..\Libraries\CMSIS\DSP_Lib;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4xx_StdPeriph_Driver\src;..\Program;..\;..\Program\drivers;..\Libraries\USBStack\INC;..\Program\math;..\Program\applications;..\Libraries\USBStack\INC;..\Libraries\CMSIS\Include;..\Program\control;..\Program\navigate
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Program
    ../Program/applications/: main.c Init.c Init.h Config.h include.h loop.c loop.h ADRC.c ADRC.h PID.c PID.h KS_Data_Transfer.c KS_Data_Transfer.h Data.c Data.h Face_track.c Face_track.h filter.c filter.h IMU.c IMU.h MotionCal.c MotionCal.h opticalflow.c opticalflow.h Param.c Param.h RC.c RC.h usb_config.c Voltage.c Voltage.h WIFI_UFO.c WIFI_UFO.h my_usb.c my_usb.h
    ../Program/drivers/: stm32f4xx_it.c stm32f4xx_it.h
  group Control
    ../Program/control/: Alt_Ctrl.c Alt_Ctrl.h AttCtrl.c AttCtrl.h Loc_Ctrl.c Loc_Ctrl.h Control.c Control.h height_ctrl.c height_ctrl.h MotorCtrl.c MotorCtrl.h
  group navigate
    ../Program/navigate/: ESO_AngularRate.h ESO_h.h Navigate.c Navigate.h TD4.h
  group Driver
    ../Program/drivers/: bsp_SysTick.c bsp_SysTick.h drv_adc.c drv_adc.h drv_esp8266.c drv_esp8266.h drv_flash.c drv_flash.h drv_fpu.c drv_fpu.h drv_i2c_soft.c drv_i2c_soft.h drv_icm20689.c drv_icm20689.h drv_led.c drv_led.h drv_nrf24l01.c drv_nrf24l01.h drv_pwm_out.c drv_pwm_out.h drv_spi.c drv_spi.h drv_spl06.c drv_spl06.h drv_usart1.c drv_usart1.h drv_usart2.c drv_usart2.h drv_usart3.c drv_usart3.h mymath.c mymath.h usbd_STM32F4xx_FS.c drv_uart4.c drv_uart4.h drv_uart5.c drv_uart5.h drv_usart6.c drv_usart6.h
  group math
    ../Program/math/: kalman3.c kalman3.h kalmanVel.c kalmanVel.h LevenbergMarquardt.c LevenbergMarquardt.h lowPassFilter.c lowPassFilter.h mathTool.c mathTool.h matrix3.c matrix3.h matrix6.c matrix6.h vector3.c vector3.h malloc.c malloc.h
  group USBStack
    ../Libraries/USBStack/SRC/: usbd_core.c usbd_core_hid.c usbd_hid.c
  group CMSIS
    ../Libraries/CMSIS/Device/: system_stm32f4xx.c startup_stm32f4xx.s
  group Library
    ../Program/applications/: stm32f4xx_conf.h
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c stm32f4xx_spi.c stm32f4xx_adc.c stm32f4xx_dma.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_wwdg.c
