# Keil uVision project Remoter.uvprojx, settings and files
target Remoter_V2.0 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: USB +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: --c99
  c include: .\Remoter;.\Driver;.\STM32_LIB\CMSIS;.\USB_hid;.\USB_library;.\STM32_LIB\LIB\inc;.\Driver\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Remoter
    ./Remoter/: main.c sysconfig.h Scheduler.c Scheduler.h Stick.c Stick.h DT.c DT.h Param.c Param.h
  group OLED
    ./Driver/OLED/: oled.c oled.h oledfont.c oledfont.h show.c show.h
  group Driver
    ./Driver/: board.c board.h stm32f10x_it.c stm32f10x_it.h Drv_LED.c Drv_LED.h Drv_Nrf24l01.c Drv_Nrf24l01.h Drv_SPI.c Drv_SPI.h Drv_Uart.c Drv_Uart.h Drv_ADC.c Drv_ADC.h Drv_I2C.c Drv_I2C.h Drv_MPU6050.c Drv_MPU6050.h Drv_Hid.c Drv_Hid.h Drv_Flash.c Drv_Flash.h Key.c Key.h
  group STM32_LIB
    ./STM32_LIB/CMSIS/: startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c core_cm3.c
    ./STM32_LIB/LIB/src/: stm32f10x_rcc.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c
    ./STM32_LIB/LIB/inc/: stm32f10x_conf.h
  group USB_lib
    ./USB_library/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c
  group USB_hid
    ./USB_hid/: usb_config.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c
  group doc
    ./doc/: readme.txt
software components: CMSIS:CORE 4.3.0
